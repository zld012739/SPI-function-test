# IAR project rtos.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX
  ICCARM.CCIncludePath2: ; app\; rtos\src; modules\; board\; ..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\Trunk\include; ..\..\RtosSalvo\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; VECT_TAB_SRAM
  ICCARM.CCIncludePath2: ; app\; modules\; board\; ..\Libraries\CMSIS\CM3\CoreSupport; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\Libraries\STM32F2xx_StdPeriph_Driver\inc
  ILINK.IlinkIcfFile: config\stm32f2xx_sram.icf
  group (top)
    ./: readme.txt
    ../../Trunk/src/timer/: timer.c
  group board
    board/: iar_stm32f207zg_sk.c
  group debug
    ../../Trunk/src/usart/: debug.c debug_usart.c
  group Salvo
    ../../RtosSalvo/Iar/Debug/Exe/: salvo.a
  group startup
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group STM32F2xx_StdPeriph_Driver
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group test
    rtos/src/: bsp.c bsp.h rtos_test_main.c stm32f2xx_conf.h stm32f2xx_it.c stm32f2xx_it.h
