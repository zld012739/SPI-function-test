# IAR project salvo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ../Inc; ../../Trunk/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: salvo.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: salvocfg.h
    ../Src/IARARM/: salvoportiararm.s79
  group src
    ../Src/: salvoarray.c salvobinsem.c salvobinsem2.c salvochk.c salvocyclic.c salvocyclic2.c salvocyclic3.c salvocyclic4.c salvocyclic5.c salvocyclic6.c salvocyclic7.c salvodebug.c salvodelay.c salvodelay2.c salvodelay3.c salvodestroy.c salvoeflag.c salvoeflag2.c salvoeid.c salvoevent.c salvoinit.c salvoinit2.c salvoinit3.c salvoinit4.c salvolicense.c salvomem.c salvomsg.c salvomsg2.c salvomsgq.c salvomsgq2.c salvomsgq3.c salvomsgq4.c salvoprio.c salvoprio2.c salvoqdel.c salvoqins.c salvorpt.c salvosched.c salvosem.c salvosem2.c salvostop.c salvotask.c salvotask2.c salvotask3.c salvotask4.c salvotask5.c salvotask6.c salvotask7.c salvotask8.c salvotick.c salvotid.c salvotimer.c salvoutil.c salvoversion.c
